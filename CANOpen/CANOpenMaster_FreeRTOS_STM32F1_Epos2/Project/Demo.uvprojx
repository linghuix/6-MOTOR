# Keil uVision project Demo.uvprojx, settings and files
target CANOpenMaster (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,DEBUG_ERR_CONSOLE_ON,DEBUG_WAR_CONSOLE_ON
  c include: ..\App;..\Bsp;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\CANOpen\inc;..\CANOpen\inc\stm32;..\App\canopen;..\EPOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group CANOpen/src
    ../CANOpen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CANOpen/inc/stm32
    ../CANOpen/inc/stm32/: applicfg.h canfestival.h timerscfg.h
  group Bsp
    ../Bsp/: bsp.c bsp_can.c bsp_timer.c bsp_usart.c
  group App
    ../App/: main.c app.c stm32f10x_it.c FreeRTOSConfig.h
  group App/canopen
    ../App/canopen/: canopen_app.c canopen_drv.c TestMaster.c
  group Doc
    ../Doc/: ReadMe.txt
  group Epos
    ../EPOS/: epos.c HW_epos.c sdo_control.c pdo_control.c gait.c nmt_control.c state_control.c
